# Keil uVision project CAN_Ex.uvprojx, settings and files
target STM32F407 Flash (ARM-ADS)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN_Ex
  c flags: Optim=4
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: CAN_Ex1.c CAN_STM32F4xx.c CAN_Cfg.h RTX_CAN.c Abstract.txt stm32f4xx_hal_msp.c stm32f4xx_it.c CAN_Ex1.h
  group can_api
    ./: iccp_canfuncs.c iccpfuncs.c
target STM32F407 Flash Loopback (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CAN_Ex +hex
  c flags: Optim=4
  c define: CAN_LOOPBACK
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:A/D Converter 2.0.0, Board Support:Graphic LCD 2.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DAC 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SRAM 1.1.0, Device:Startup 2.1.0
